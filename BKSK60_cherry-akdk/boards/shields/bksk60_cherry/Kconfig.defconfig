## BKSK60_cherry-akdk/boards/shields/bksk60_cherry/Kconfig.defconfig
```kconfig
if SHIELD_BKSK60_CHERRY

config ZMK_KEYBOARD_NAME
    default "bksk60_cherry"

endif
```
